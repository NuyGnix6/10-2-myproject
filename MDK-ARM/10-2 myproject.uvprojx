# Keil uVision project 10-2 myproject.uvprojx, settings and files
target 10-2 myproject (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 10-2 myproject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../mydriver;../Hardware;../Tasks;../Middlewares/LVGL;../Middlewares/LVGL/lvgl;../Middlewares/LVGL/lvgl/src;../Core/Src/ui
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/LVGL;../Middlewares/LVGL/lvgl;../Middlewares/LVGL/lvgl/src;../Core/Src/ui
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group mydriver
    ../mydriver/: bsp.c bsp.h
  group Hardware
    ../Hardware/: Buzzer.c Buzzer.h DHT11.c DHT11.h Key.c Key.h Light.c Light.h MyFlash.c MyFlash.h uart.c uart.h ESP.c ESP.h bsp_ili9341.c bsp_ili9341.h lv_port_disp_v9.c bsp_ft6336.c bsp_ft6336.h lv_port_indev_v9.c
  group Tasks
    ../Tasks/: AlarmTask.c AlarmTask.h AppData.h CMDTask.c CMDTask.h DHT11Task.c DHT11Task.h KeyTask.c KeyTask.h LightTask.c LightTask.h UartTask.c UartTask.h LVGLTask.c LVGLTask.h
  group LVGL
    ../Middlewares/LVGL/lvgl/src/: lv_init.c
    ../Middlewares/LVGL/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../Middlewares/LVGL/lvgl/src/debugging/monkey/: lv_monkey.c
    ../Middlewares/LVGL/lvgl/src/debugging/sysmon/: lv_sysmon.c
    ../Middlewares/LVGL/lvgl/src/debugging/test/: lv_test_display.c lv_test_fs.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../Middlewares/LVGL/lvgl/src/debugging/vg_lite_tvg/: vg_lite_matrix.c
    ../Middlewares/LVGL/lvgl/src/display/: lv_display.c
    ../Middlewares/LVGL/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Middlewares/LVGL/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../Middlewares/LVGL/lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../Middlewares/LVGL/lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../Middlewares/LVGL/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../Middlewares/LVGL/lvgl/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    ../Middlewares/LVGL/lvgl/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    ../Middlewares/LVGL/lvgl/src/draw/nanovg/: lv_draw_nanovg.c lv_draw_nanovg_3d.c lv_draw_nanovg_arc.c lv_draw_nanovg_border.c lv_draw_nanovg_box_shadow.c lv_draw_nanovg_fill.c lv_draw_nanovg_grad.c lv_draw_nanovg_image.c lv_draw_nanovg_label.c lv_draw_nanovg_layer.c lv_draw_nanovg_line.c lv_draw_nanovg_mask_rect.c lv_draw_nanovg_triangle.c lv_draw_nanovg_vector.c lv_nanovg_fbo_cache.c lv_nanovg_image_cache.c lv_nanovg_utils.c
    ../Middlewares/LVGL/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
    ../Middlewares/LVGL/lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../Middlewares/LVGL/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../Middlewares/LVGL/lvgl/src/draw/snapshot/: lv_snapshot.c
    ../Middlewares/LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../Middlewares/LVGL/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../Middlewares/LVGL/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../Middlewares/LVGL/lvgl/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../Middlewares/LVGL/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_bitmap_font_cache.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../Middlewares/LVGL/lvgl/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm_common.c lv_linux_drm_egl.c
    ../Middlewares/LVGL/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
    ../Middlewares/LVGL/lvgl/src/drivers/display/ft81x/: lv_ft81x.c
    ../Middlewares/LVGL/lvgl/src/drivers/display/ili9341/: lv_ili9341.c
    ../Middlewares/LVGL/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../Middlewares/LVGL/lvgl/src/drivers/display/nv3007/: lv_nv3007.c
    ../Middlewares/LVGL/lvgl/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
    ../Middlewares/LVGL/lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../Middlewares/LVGL/lvgl/src/drivers/display/st7735/: lv_st7735.c
    ../Middlewares/LVGL/lvgl/src/drivers/display/st7789/: lv_st7789.c
    ../Middlewares/LVGL/lvgl/src/drivers/display/st7796/: lv_st7796.c
    ../Middlewares/LVGL/lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../Middlewares/LVGL/lvgl/src/drivers/draw/eve/: lv_draw_eve_display.c
    ../Middlewares/LVGL/lvgl/src/drivers/evdev/: lv_evdev.c
    ../Middlewares/LVGL/lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../Middlewares/LVGL/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../Middlewares/LVGL/lvgl/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_texture.c
    ../Middlewares/LVGL/lvgl/src/drivers/opengles/assets/: lv_opengles_shader.c
    ../Middlewares/LVGL/lvgl/src/drivers/opengles/glad/src/: egl.c gl.c gles2.c
    ../Middlewares/LVGL/lvgl/src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c
    ../Middlewares/LVGL/lvgl/src/drivers/qnx/: lv_qnx.c
    ../Middlewares/LVGL/lvgl/src/drivers/sdl/: lv_sdl_egl.c lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_sw.c lv_sdl_texture.c lv_sdl_window.c
    ../Middlewares/LVGL/lvgl/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    ../Middlewares/LVGL/lvgl/src/drivers/wayland/: lv_wayland.c lv_wl_egl_backend.c lv_wl_g2d_backend.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_seat.c lv_wl_shm_backend.c lv_wl_touch.c lv_wl_window.c lv_wl_xdg_shell.c
    ../Middlewares/LVGL/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../Middlewares/LVGL/lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ../Middlewares/LVGL/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../Middlewares/LVGL/lvgl/src/font/binfont_loader/: lv_binfont_loader.c
    ../Middlewares/LVGL/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../Middlewares/LVGL/lvgl/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../Middlewares/LVGL/lvgl/src/font/imgfont/: lv_imgfont.c
    ../Middlewares/LVGL/lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../Middlewares/LVGL/lvgl/src/layouts/: lv_layout.c
    ../Middlewares/LVGL/lvgl/src/layouts/flex/: lv_flex.c
    ../Middlewares/LVGL/lvgl/src/layouts/grid/: lv_grid.c
    ../Middlewares/LVGL/lvgl/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ../Middlewares/LVGL/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../Middlewares/LVGL/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Middlewares/LVGL/lvgl/src/libs/bmp/: lv_bmp.c
    ../Middlewares/LVGL/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/LVGL/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../Middlewares/LVGL/lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../Middlewares/LVGL/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../Middlewares/LVGL/lvgl/src/libs/gif/: gif.c
    ../Middlewares/LVGL/lvgl/src/libs/gltf/gltf_environment/: lv_gltf_ibl_sampler.c
    ../Middlewares/LVGL/lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ../Middlewares/LVGL/lvgl/src/libs/gltf/math/: lv_3dmath.c
    ../Middlewares/LVGL/lvgl/src/libs/gstreamer/: lv_gstreamer.c
    ../Middlewares/LVGL/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../Middlewares/LVGL/lvgl/src/libs/libpng/: lv_libpng.c
    ../Middlewares/LVGL/lvgl/src/libs/libwebp/: lv_libwebp.c
    ../Middlewares/LVGL/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../Middlewares/LVGL/lvgl/src/libs/lz4/: lz4.c
    ../Middlewares/LVGL/lvgl/src/libs/nanovg/: nanovg.c
    ../Middlewares/LVGL/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/LVGL/lvgl/src/libs/rle/: lv_rle.c
    ../Middlewares/LVGL/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../Middlewares/LVGL/lvgl/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../Middlewares/LVGL/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Middlewares/LVGL/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../Middlewares/LVGL/lvgl/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c
    ../Middlewares/LVGL/lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
    ../Middlewares/LVGL/lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    ../Middlewares/LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Middlewares/LVGL/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../Middlewares/LVGL/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../Middlewares/LVGL/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Middlewares/LVGL/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../Middlewares/LVGL/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../Middlewares/LVGL/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares/LVGL/lvgl/src/others/translation/: lv_translation.c
    ../Middlewares/LVGL/lvgl/src/stdlib/: lv_mem.c
    ../Middlewares/LVGL/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Middlewares/LVGL/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Middlewares/LVGL/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Middlewares/LVGL/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Middlewares/LVGL/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../Middlewares/LVGL/lvgl/src/themes/: lv_theme.c
    ../Middlewares/LVGL/lvgl/src/themes/default/: lv_theme_default.c
    ../Middlewares/LVGL/lvgl/src/themes/mono/: lv_theme_mono.c
    ../Middlewares/LVGL/lvgl/src/themes/simple/: lv_theme_simple.c
    ../Middlewares/LVGL/lvgl/src/tick/: lv_tick.c
    ../Middlewares/LVGL/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../Middlewares/LVGL/lvgl/src/widgets/animimage/: lv_animimage.c
    ../Middlewares/LVGL/lvgl/src/widgets/arc/: lv_arc.c
    ../Middlewares/LVGL/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../Middlewares/LVGL/lvgl/src/widgets/bar/: lv_bar.c
    ../Middlewares/LVGL/lvgl/src/widgets/button/: lv_button.c
    ../Middlewares/LVGL/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Middlewares/LVGL/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/LVGL/lvgl/src/widgets/canvas/: lv_canvas.c
    ../Middlewares/LVGL/lvgl/src/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/LVGL/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Middlewares/LVGL/lvgl/src/widgets/gif/: lv_gif.c
    ../Middlewares/LVGL/lvgl/src/widgets/image/: lv_image.c
    ../Middlewares/LVGL/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middlewares/LVGL/lvgl/src/widgets/ime/: lv_ime_pinyin.c
    ../Middlewares/LVGL/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/LVGL/lvgl/src/widgets/label/: lv_label.c
    ../Middlewares/LVGL/lvgl/src/widgets/led/: lv_led.c
    ../Middlewares/LVGL/lvgl/src/widgets/line/: lv_line.c
    ../Middlewares/LVGL/lvgl/src/widgets/list/: lv_list.c
    ../Middlewares/LVGL/lvgl/src/widgets/lottie/: lv_lottie.c
    ../Middlewares/LVGL/lvgl/src/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middlewares/LVGL/lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../Middlewares/LVGL/lvgl/src/widgets/roller/: lv_roller.c
    ../Middlewares/LVGL/lvgl/src/widgets/scale/: lv_scale.c
    ../Middlewares/LVGL/lvgl/src/widgets/slider/: lv_slider.c
    ../Middlewares/LVGL/lvgl/src/widgets/span/: lv_span.c
    ../Middlewares/LVGL/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/LVGL/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/lvgl/src/widgets/switch/: lv_switch.c
    ../Middlewares/LVGL/lvgl/src/widgets/table/: lv_table.c
    ../Middlewares/LVGL/lvgl/src/widgets/tabview/: lv_tabview.c
    ../Middlewares/LVGL/lvgl/src/widgets/textarea/: lv_textarea.c
    ../Middlewares/LVGL/lvgl/src/widgets/tileview/: lv_tileview.c
    ../Middlewares/LVGL/lvgl/src/widgets/win/: lv_win.c
  group UI
    ../Core/Src/ui/: myui_rewriter.c myui_rewriter.h
    ../Core/Src/ui/Font/: lv_font_ui_18.c lv_font_ui_26.c lv_font_num_32.c
software components: CMSIS:CORE 4.3.0
